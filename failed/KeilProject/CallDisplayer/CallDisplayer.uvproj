# Keil uVision project CallDisplayer.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CallDisplayer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: STARTUP.A51
    ../PublicSources/: Delay.c
    ./Sources/: Main.c DotMatrix.c
  group Headers
    ../PublicSources/Headers/: PreMacro.h
    ./Sources/Headers/: DotMatrix.h
