# Keil uVision project CallMaster.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CallMaster +hex
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: STARTUP.A51
    ./Sources/: Main.c LCD12864.c
    ../PublicSources/: Delay.c
  group Headers
    ../PublicSources/Headers/: PreMacro.h
    ./Sources/Headers/: LCDCharacters.h
