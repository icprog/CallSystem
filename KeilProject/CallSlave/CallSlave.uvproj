# Keil uVision project CallSlave.uvproj, settings and files
target Main (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: CallSlave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: STARTUP.A51
    ./Sources/: Main.c Keyboard.c
  group Headers
    ../PublicSources/Headers/: PreMacro.h Serial.h
  group Public
    ../PublicSources/: Delay.c Serial.c
