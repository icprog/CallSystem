# Keil uVision project CallDisplayer.uvproj, settings and files
target Main (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: CallDisplayer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Sources
    ./: STARTUP.A51
    ./Sources/: Main.c DotMatrix.c DotMatrixExec.c DS1302.c
  group Headers
    ../PublicSources/Headers/: PreMacro.h Serial.h
    ./Sources/Headers/: DotMatrixExec.h DS1302.h
  group Public
    ../PublicSources/: Delay.c Serial.c
